inherit setuptools
require python-unidecode.inc

