inherit setuptools
require python-blessings.inc
