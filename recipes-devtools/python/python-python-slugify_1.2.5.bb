inherit setuptools
require python-python-slugify.inc

