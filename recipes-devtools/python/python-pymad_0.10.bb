inherit setuptools
require python-pymad.inc

