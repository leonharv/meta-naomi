inherit setuptools
require python-cmuclmtk.inc
