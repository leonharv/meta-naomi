inherit setuptools
require python-apscheduler.inc

